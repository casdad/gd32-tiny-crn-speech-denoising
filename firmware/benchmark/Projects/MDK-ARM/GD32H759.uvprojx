# Keil uVision project GD32H759.uvprojx, settings and files
target USART (6220000::V6.22::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32H759 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H7XX
  c include: ..\..\Drivers\CMSIS;..\..\Drivers\CMSIS\GD\GD32H7xx\Include;..\..\Drivers\GD32H7xx_standard_peripheral\Include;..\..\Drivers;..\..\Middlewares;..\..\Middlewares\FATFS;..\..\User;..\..\Middlewares\AI\inc;..\..\Middlewares\AI\inc\operators\cmsis_nn;..\..\Middlewares\AI\inc\operators\f32;..\..\Middlewares\AI\inc\operators\third_party
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Startup
    ../../Drivers/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group User
    ../../User/: main.c sd_wav_recorder.c gd32h7xx_it.c buffers.c crn_model.c crn_ai_stubs.c nn_model_configure.c perf_meter.c
    ../../Drivers/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/GD32H7xx_standard_peripheral
    ../../Drivers/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/Codec/: codec.c
    ../../Drivers/BSP/IF_PORT/: if_port.c
    ../../Drivers/BSP/LT768/: LT768.c
    ../../Drivers/BSP/LT768_Demo/: LT768_Demo.c
    ../../Drivers/BSP/LT768_Lib/: LT768_Lib.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/TOUCH/: touch.c
    ../../Drivers/BSP/SDIO/: sd_conf.c sdio_sdcard.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/SDRAM/: sdram.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/: ff.c diskio.c ffsystem.c ffunicode.c
  group Middlewares/AI
    ../../Middlewares/AI/: GD_LIB_CM7_v210.lib
  group Readme
    ../../: readme.txt
  group RNNoise
    ../../RNNoise_src/: celt_lpc.c denoise.c kiss_fft_rnnoise.c pitch.c rnn.c rnn_data.c
